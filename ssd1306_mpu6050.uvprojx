# Keil uVision project ssd1306_mpu6050.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32L031K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ssd1306_mpu6050
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c mpu6050.c mpu6050.h delay.c delay.h i2c.c i2c.h soft_i2c.c soft_i2c.h ssd1306.c ssd1306.h ui.c ui.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.12.2
